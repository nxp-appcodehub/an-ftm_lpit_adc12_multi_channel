# IAR project ftm_lpit_adc12_multi_channel.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE17Z256xxx7 NXP MKE17Z256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKE17Z256VLL7; FRDM_KE17Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; frdmke17z/demo_apps/ftm_lpit_adc12; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ftm_lpit_adc12_multi_channel.out
  ILINK.IlinkIcfFile: MKE17Z7/iar/MKE17Z256xxx7_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKE17Z256VLL7; FRDM_KE17Z; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group (top)
    ./: ftm_lpit_adc12.mex
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MKE17Z7.h MKE17Z7_features.h system_MKE17Z7.c system_MKE17Z7.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_adc12.c fsl_adc12.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_lpit.c fsl_lpit.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_trgmux.c fsl_trgmux.h
  group frdmke17z/demo_apps/ftm_lpit_adc12
    frdmke17z/demo_apps/ftm_lpit_adc12/: ftm_lpit_adc12.bin
  group MKE17Z7/iar
    MKE17Z7/iar/: MKE17Z256xxx7_flash.icf
  group source
    source/: ftm_lpit_adc12.c
  group startup
    startup/: startup_MKE17Z7.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
